# IAR project uip_webserver.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: app; board; modules; uip; uip\httpd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uip_demo.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; SDRAM_DEBUG
  ILINK.IlinkIcfFile: config\LPC2478_SDRAM.icf
  group (top)
    ./: readme.txt
  group app
    app/: algo.c algo.h button_settings.c button_settings.h cd_class.c cd_class.h cdc_cmd.h cdc_desc.h clock-arch.c cursor_arrow.c cursor_arrow.h drv_touch_scr.c drv_touch_scr.h gui.c gui.h iar_logo.c includes.h lamp_off.c lamp_off.h lamp_on.c lamp_on.h main.c main.h Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c uart.c uart.h usb_cnfg.h usb_dev_desc.c usb_dev_desc.h usb_hooks.c usb_hooks.h
    modules/: usb_buffer.c usb_buffer.h usb_desc.h usb_hw.c usb_hw.h usb_t9.c usb_t9.h
  group app/Config
    app/: uip-conf.h uipopt.h
  group board
    board/: sys.c
  group config
    config/: LPC2478_Flash.icf
  group Modules
    modules/: drv_glcd.c LPC24xx_enet.c sdram_64M_32bit_drv.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
